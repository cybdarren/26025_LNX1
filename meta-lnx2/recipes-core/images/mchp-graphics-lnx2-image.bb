require ../meta-mchp/meta-mchp-mpu/recipes-mchp/images/mchp-graphics-image.bb

DESCRIPTION = "Custom image with graphics for LNX2 class"
EXTRA_IMAGE_FEATURES += " tools-debug"

