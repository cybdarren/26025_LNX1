require ../meta-mchp/meta-mchp-mpu/meta-mchp-mpu-apps/recipes-mchp/images/mchp-graphics-image.bb
DESCRIPTION = "Custom image with graphics for LNX1 class"
EXTRA_IMAGE_FEATURES += " tools-debug"

